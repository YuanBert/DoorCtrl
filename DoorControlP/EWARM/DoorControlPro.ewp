# IAR project DoorControlPro.ewp, settings and files
configuration DoorControlPro (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../../../../../../Inc; ../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: DoorControlPro.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Middlewares
    ./: 
  group Middlewares/USB_Device_Library
    ./: 
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../../../../../../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ./: 
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_flash.c
  group Application
    ./: 
  group Application/User
    ./: 
    ../../../../../../Src/: dma.c usbd_cdc_if.c usb_device.c usbd_conf.c stm32f1xx_hal_msp.c adc.c usbd_desc.c stm32f1xx_it.c gpio.c usart.c main.c tim.c
  group Application/EWARM
    ./:  startup_stm32f103xe.s
